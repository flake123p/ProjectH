# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: test
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c a.c b.c c.c
