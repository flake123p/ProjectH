# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: test
  c flags: Optimize=9 SizeSpeed=1
  link misc: OVERLAY(* ! ?PR?FUNC?FUNC)
  group Source Group 1
    ./: main.s func.c
