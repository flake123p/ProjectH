# Keil uVision project DualProjects.uvproj, settings and files
target Boot_Loader (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ..\boot
  c flags: Optimize=8 SizeSpeed=1
  asm define: APP1
  link misc: MERGEPUBLICS
  group Boot_Loader_Files
    ./source_boot/: boot.c STARTUP.A51 App1Entry.Asm INIT.A51
  group Application_Files
    ./source_app1/: app1.c STARTUP_Lite.A51 App1Call.Asm INIT.A51
    ./: boot
  group Misc
    ./: Debug_Load.INI Abstract.txt
target Application (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ..\app1 +hex
  c flags: Optimize=8 SizeSpeed=1
  asm define: APP1
  link misc: MERGEPUBLICS
